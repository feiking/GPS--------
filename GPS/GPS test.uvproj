# Keil uVision project GPS test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GPS test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c GPS.c LCD.c display.c
  group head
    ./: LCD.h GPS.h display.h
